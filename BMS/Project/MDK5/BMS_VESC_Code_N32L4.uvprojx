# Keil uVision project BMS_VESC_Code_N32L4.uvprojx, settings and files
target bms_adv2 (6230000::V6.23::ARMCLANG)
  device: N32L403K8 NSING
  pack: NSING.N32L40x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bms_adv2 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: N32L40X USE_STDPERIPH_DRIVER ADV2 S50S
  c include: ..\..\Library\Nationstech.N32L40x_Library.1.2.2\firmware\CMSIS\core;..\..\Library\Nationstech.N32L40x_Library.1.2.2\firmware\CMSIS\device;..\..\Library\Nationstech.N32L40x_Library.1.2.2\firmware\n32l40x_std_periph_driver\inc;..\..\Source\App;..\..\Source\Drive;..\..\Source\DVC1124;..\..\Source\User;..\..\Source\VESC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../../Source/User/: main.c n32l40x_it.c
    ../../Library/Nationstech.N32L40x_Library.1.2.2/firmware/CMSIS/device/: system_n32l40x.c
  group Startup
    ../../Library/Nationstech.N32L40x_Library.1.2.2/firmware/CMSIS/device/startup/: startup_n32l40x.s
  group App
    ../../Source/App/: led_app.c flag.c vesc_can.c vesc_can_app.c key_app.c power_app.c BMS_Protection.c
  group DVC1124
    ../../Source/DVC1124/: DVC11XX.c DVC1124_init.c DVC1124_app.c Voltage.c Sleep.c Temperature.c Current.c BalanceDemo.c CellBalance.c
  group Drive
    ../../Source/Drive/: led.c User_Delay_Config.c time6.c ldo.c mos.c charger.c can.c key.c i2c.c ppm.c pwr.c gp2.c iwdg.c wwdg.c
  group VESC
    ../../Source/VESC/: buffer.c crc.c
  group Library
    ../../Library/Nationstech.N32L40x_Library.1.2.2/firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_can.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_tim.c n32l40x_flash.c n32l40x_dbg.c n32l40x_exti.c n32l40x_wwdg.c
